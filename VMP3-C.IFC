Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\DennisHoogenboezem\HSR Groep BV\Unitura - Documenten (2)\R&D\Producttekeningen\1. HOUTEN VOORZIENINGEN (wood)\GOOTKASTEN (gutter boxes)\GZP3-HMP3-VMP3\VMP3 brontekeningen\VMP3-C.IFC
Time: 2026-04-22T09:04:55+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
